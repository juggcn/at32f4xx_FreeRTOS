# Keil uVision project at32f4xx.uvprojx, settings and files
target at32f415cbt7 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F415CBT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415CBT7,USE_STDPERIPH_DRIVER, AT_START_F415_V1_0,__TARGET_FPU_SOFTVFP
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\LED_Toggle;..\..\..\..\..\AT32_Board;..\..\..\..\..\..\Middlewares\UCOSIII\uC-CPU;..\..\..\..\..\..\Middlewares\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\..\Middlewares\UCOSIII\uC-LIB;..\..\..\..\..\..\Middlewares\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\..\..\..\Middlewares\UCOSIII\uCOS-III\Source;..\..\..\..\..\..\Middlewares\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\..\Middlewares\UCOSIII\EvalBoards\BSP;..\..\..\..\..\..\Middlewares\UCOSIII\EvalBoards\uCOS-III
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f415cbt7.s startup_at32f415cct7.s
  group AT32Periph
    ../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group FreeRTOS
    ../../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Sys
    ../../../Sys/Src/: cpu_utils.c
target at32f415cct7 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F415CBT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: as above
  output: LED
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415CCT7,USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\Middlewares\FreeRTOS\include;..\..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\..\..\Middlewares\FreeRTOS;..\..\..\Sys\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
